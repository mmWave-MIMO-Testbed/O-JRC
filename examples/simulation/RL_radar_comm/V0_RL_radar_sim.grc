options:
  parameters:
    author: Ceyhun D. Ozkaptan
    category: Custom
    description: The Ohio State University
    generate_options: qt_gui
    id: mimo_ofdm_radar_sim
    output_language: python
    title: MIMO OFDM Radar Simulation
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: ofdm_config.N_ltf
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: ofdm_config.N_tx
  states: {}
- name: R_max
  id: variable
  parameters:
    value: 3e8*fft_len/(2*samp_rate)
  states: {}
- name: R_res
  id: variable
  parameters:
    value: 3e8/(2*samp_rate)
  states: {}
- name: TX1_RXs
  id: variable
  parameters:
    value: '[1*wavelength, 3*wavelength]'
  states: {}
- name: TX2_RXs
  id: variable
  parameters:
    value: '[3/2*wavelength, 7/2*wavelength]'
  states: {}
- name: TX3_RXs
  id: variable
  parameters:
    value: '[4/2*wavelength, 8/2*wavelength]'
  states: {}
- name: TX4_RXs
  id: variable
  parameters:
    value: '[5/2*wavelength, 9/2*wavelength]'
  states: {}
- name: angle_axis
  id: variable
  parameters:
    value: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
  states: {}
- name: angle_res
  id: variable
  parameters:
    value: np.rad2deg(np.arcsin(2/(N_tx*N_rx)))
  states: {}
- name: capture_radar
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 5,2,1,2
    label: 'Capture Radar Image '
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: chan_est_path
  id: variable
  parameters:
    value: parrent_path+"/RL_ResourceAllocation_Data/chan_est.csv"
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: data_carriers_64
  id: variable
  parameters:
    value: list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(2**6)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: interp_factor_angle
  id: variable
  parameters:
    value: '16'
  states: {}
- name: interp_factor_range
  id: variable
  parameters:
    value: '8'
  states: {}
- name: max_ofdm_symbols
  id: variable
  parameters:
    value: '800'
  states: {}
- name: noise_figure_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    label: Noise Figure (dB)
    orient: Qt.Horizontal
    start: '1'
    step: '0.1'
    stop: '40'
    value: '10'
  states: {}
- name: noise_var
  id: variable
  parameters:
    value: 4.003886160000000e-21*samp_rate*10**(noise_figure_dB/10.0)
  states: {}
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/RL_ResourceAllocation_Data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/haocheng/O-JRC/examples"'
  states: {}
- name: pilot_carriers_64
  id: variable
  parameters:
    comment: range(-16,0) + range(1,17)
    value: (-21, -7, 7, 21)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))
  states: {}
- name: radar_chan_file
  id: variable
  parameters:
    value: parrent_path+"/RL_ResourceAllocation_Data/radar_chan.csv"
  states: {}
- name: radar_log_file
  id: variable
  parameters:
    value: parrent_path+"/RL_ResourceAllocation_Data/radar_log.csv"
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: freq+20e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: save_radar_log
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0,1,2
    label: Save Radar Log
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: target_data_file
  id: variable
  parameters:
    value: parrent_path+"/RL_ResourceAllocation_Data/target_data.csv"
  states: {}
- name: trgt_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,4
    label: Target Angle
    orient: Qt.Horizontal
    rangeType: int
    start: '-89'
    step: '1'
    stop: '+89'
    value: '0'
  states: {state: disabled}
- name: trgt_angle_multi
  id: variable
  parameters:
    value: np.array([0.0, 10.0], dtype=float)
  states: {}
- name: trgt_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: Target Distance
    orient: Qt.Horizontal
    start: '0.1'
    step: '1'
    stop: R_max
    value: '10'
  states: {state: disabled}
- name: trgt_range_multi
  id: variable
  parameters:
    value: np.array([5.0, 5.5], dtype=float)
  states: {}
- name: trgt_rcs_dbsm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: trgt_rcs_multi
  id: variable
  parameters:
    comment: RCS_2 = RCS_1 * (R_2 / R_1)^4
    value: '[10**(trgt_rcs_dbsm/10.0), 10**(trgt_rcs_dbsm/10.0)]'
  states: {}
- name: trgt_velocity
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,4
    label: Target Velocity
    orient: Qt.Horizontal
    start: '-40'
    step: '1'
    stop: '40'
    value: '0'
  states: {state: disabled}
- name: trgt_velocity_multi
  id: variable
  parameters:
    value: '[0.0] * len(trgt_range_multi)'
  states: {}
- name: tx_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: TX Gain
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.05'
    stop: '10'
    value: '0.1'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_freq
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(noise_var)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(noise_var)
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    affinity: '9'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {state: bypassed}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '5000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: max_ofdm_symbols
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    comment: |-
      window.hanning(fft_len*interp_factor)
      window.rectangular(fft_len*interp_factor)
    fft_size: fft_len*interp_factor_range
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_len*interp_factor_range)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    comment: |-
      window.hanning(N_tx*N_rx*interp_factor)
      window.rectangular(N_tx*N_rx*interp_factor)
    fft_size: N_tx*N_rx*interp_factor_angle
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N_tx*N_rx*interp_factor_angle)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: max_ofdm_symbols
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: max_ofdm_symbols
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2_0_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: max_ofdm_symbols
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: helper_ofdm_cyclic_prefix_remover_0_0_0
  id: helper_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {state: disabled}
- name: helper_zero_pad_0_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: helper_zero_pad_0_0_1
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: helper_zero_pad_0_0_1_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: mimo_ofdm_jrc_Multi_targets_simulator_0
  id: mimo_ofdm_jrc_Multi_targets_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    comment: RCS = 10**(trgt_rcs_dbsm/10.0)
    csv_path: /home/haocheng/O-JRC/examples/RL_ResourceAllocation_Data/target_data.csv
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX1_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {}
- name: mimo_ofdm_jrc_Multi_targets_simulator_0_0
  id: mimo_ofdm_jrc_Multi_targets_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    comment: RCS = 10**(trgt_rcs_dbsm/10.0)
    csv_path: /home/haocheng/O-JRC/examples/RL_ResourceAllocation_Data/target_data.csv
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX2_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {}
- name: mimo_ofdm_jrc_Multi_targets_simulator_0_0_0
  id: mimo_ofdm_jrc_Multi_targets_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    comment: RCS = 10**(trgt_rcs_dbsm/10.0)
    csv_path: /home/haocheng/O-JRC/examples/RL_ResourceAllocation_Data/target_data.csv
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX3_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {}
- name: mimo_ofdm_jrc_Multi_targets_simulator_0_0_0_0
  id: mimo_ofdm_jrc_Multi_targets_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    comment: RCS = 10**(trgt_rcs_dbsm/10.0)
    csv_path: /home/haocheng/O-JRC/examples/RL_ResourceAllocation_Data/target_data.csv
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX4_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {}
- name: mimo_ofdm_jrc_gui_heatmap_plot_0
  id: mimo_ofdm_jrc_gui_heatmap_plot
  parameters:
    autoscale_z: 'True'
    axis_x: angle_axis
    axis_y: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor_range)
    db_scale: 'False'
    digital_control: ''
    dynamic_range_db: '15'
    interval: '100'
    label: Range-Angle Image
    len_key: '"packet_len"'
    sivers_angle_log: ''
    vlen: N_tx*N_rx*interp_factor_angle
    x_axis_ticks: '[-90, 90, 10]'
    xlabel: '"Angle"'
    y_axis_ticks: '[0, 32, 4]'
    ylabel: '"Range (m)"'
  states: {state: disabled}
- name: mimo_ofdm_jrc_gui_heatmap_plot_digital_0
  id: mimo_ofdm_jrc_gui_heatmap_plot_digital
  parameters:
    autoscale_z: 'False'
    axis_x: angle_axis
    axis_y: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    comment: dynamic_range = 9 dB
    db_scale: 'False'
    dynamic_range_db: '9'
    interval: '100'
    label: Range-Angle Image
    len_key: '"packet_len"'
    vlen: N_tx*N_rx*interp_factor_angle
    x_axis_ticks: '[-70, 70, 10]'
    xlabel: '"Angle"'
    y_axis_ticks: '[0, 10, 1]'
    ylabel: '"Range (m)"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[0,40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Angle Estimate"'
    time_window: '10'
    y_axis_lim: '[-70,70]'
    y_label: '"Angle (degree)"'
    y_tag: '"angle"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_2
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Range Estimate"'
    time_window: '10'
    y_axis_lim: '[0,20]'
    y_label: '"Range (m)"'
    y_tag: '"range"'
  states: {}
- name: mimo_ofdm_jrc_matrix_transpose_0
  id: mimo_ofdm_jrc_matrix_transpose
  parameters:
    debug: 'False'
    input_len: fft_len*interp_factor_range
    interp_factor: interp_factor_angle
    len_key: '"packet_len"'
    minoutbuf: '10000'
    output_len: N_tx*N_rx
  states: {}
- name: mimo_ofdm_jrc_mimo_ofdm_radar_0
  id: mimo_ofdm_jrc_mimo_ofdm_radar
  parameters:
    N_pre: len(ofdm_config.l_stf_ltf_64)+1
    N_rx: N_rx
    N_sym: N_tx
    N_tx: N_tx
    background_record: 'False'
    background_removal: 'False'
    capture_sig: capture_radar
    debug: 'False'
    enable_tx_interleave: 'False'
    fft_len: fft_len
    interp_factor: interp_factor_range
    len_tag_key: '"packet_len"'
    radar_chan_file: radar_chan_file
    record_len: '8'
    stats_record: 'True'
  states: {}
- name: mimo_ofdm_jrc_mimo_precoder_0
  id: mimo_ofdm_jrc_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    chan_est_file: '""'
    chan_est_smoothing: 'False'
    data_carriers: data_carriers_64
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: max_ofdm_symbols
    phased_steering: 'False'
    pilot_carriers: pilot_carriers_64
    pilot_symbols: pilot_symbols
    radar_aided: 'False'
    radar_log_file: '""'
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: 'False'
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_0
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {}
- name: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0
  id: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {}
- name: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0_0
  id: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {}
- name: mimo_ofdm_jrc_packet_switch_0
  id: mimo_ofdm_jrc_packet_switch
  parameters:
    packet_info_file: packet_data_file
    period_ms: '50'
  states: {}
- name: mimo_ofdm_jrc_range_angle_estimator_0
  id: mimo_ofdm_jrc_range_angle_estimator
  parameters:
    angle_bins: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
    debug: 'False'
    len_key: '"packet_len"'
    noise_discard_angle: angle_res*2
    noise_discard_range: R_res*2
    power_threshold: '0'
    range_bins: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor_range)
    snr_threshold: '20'
    stats_path: radar_log_file
    stats_record: save_radar_log
    stats_signal_strength_path: '""'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: mimo_ofdm_jrc_socket_pdu_jrc_0
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '10000'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: mimo_ofdm_jrc_stream_encoder_0
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: len(data_carriers_64)
    debug: 'False'
    mod_encode: mimo_ofdm_jrc.QPSK_3_4
  states: {}
- name: mimo_ofdm_jrc_target_simulator_0
  id: mimo_ofdm_jrc_target_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    comment: RCS = 10**(trgt_rcs_dbsm/10.0)
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX1_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {state: disabled}
- name: mimo_ofdm_jrc_target_simulator_0_0
  id: mimo_ofdm_jrc_target_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX2_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {state: disabled}
- name: mimo_ofdm_jrc_target_simulator_0_0_0
  id: mimo_ofdm_jrc_target_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX3_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {state: disabled}
- name: mimo_ofdm_jrc_target_simulator_0_0_0_0
  id: mimo_ofdm_jrc_target_simulator
  parameters:
    azimuth: trgt_angle_multi
    center_freq: rf_freq
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX4_RXs
    range: trgt_range_multi
    rcs: trgt_rcs_multi
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity_multi
  states: {state: disabled}
- name: mimo_ofdm_jrc_zero_pad_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: ofdm_config
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 4
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: Signal RX1
    size: fft_len*12
    srate: '1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: RX2
    size: packet_len*5
    srate: '1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    label1: ''
    label2: ''
    name: Signal TX1
    size: (fft_len+cp_len)*12
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RANGE-ANGLE
  states: {}
- name: virtual_sink_0_1_1
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_sink_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: TX4
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RANGE-ANGLE
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX4
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '4']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '4']
- [blocks_add_xx_0, '0', virtual_sink_0_1_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', mimo_ofdm_jrc_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', helper_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', helper_zero_pad_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', helper_zero_pad_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', mimo_ofdm_jrc_gui_heatmap_plot_0, '0']
- [blocks_nlog10_ff_0, '0', mimo_ofdm_jrc_gui_heatmap_plot_digital_0, '0']
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [blocks_throttle_0, '0', mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0, '0']
- [blocks_throttle_0_0, '0', helper_ofdm_cyclic_prefix_remover_0_0_0, '0']
- [blocks_throttle_0_0, '0', mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', virtual_sink_0_1, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0, '0', virtual_sink_0_1_1, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0_0, '0', virtual_sink_0_1_1_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '4']
- [fft_vxx_0_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '5']
- [fft_vxx_0_1, '0', mimo_ofdm_jrc_matrix_transpose_0, '0']
- [fft_vxx_0_1_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_1_0, '0', mimo_ofdm_jrc_range_angle_estimator_0, '0']
- [fft_vxx_0_2, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_2_0, '0', digital_ofdm_cyclic_prefixer_0_0_0, '0']
- [fft_vxx_0_2_0_0, '0', digital_ofdm_cyclic_prefixer_0_0_0_0, '0']
- [mimo_ofdm_jrc_Multi_targets_simulator_0, '0', blocks_add_xx_0, '0']
- [mimo_ofdm_jrc_Multi_targets_simulator_0, '1', blocks_add_xx_0_0, '0']
- [mimo_ofdm_jrc_Multi_targets_simulator_0_0, '0', blocks_add_xx_0, '1']
- [mimo_ofdm_jrc_Multi_targets_simulator_0_0, '1', blocks_add_xx_0_0, '1']
- [mimo_ofdm_jrc_Multi_targets_simulator_0_0_0, '0', blocks_add_xx_0, '3']
- [mimo_ofdm_jrc_Multi_targets_simulator_0_0_0, '1', blocks_add_xx_0_0, '2']
- [mimo_ofdm_jrc_Multi_targets_simulator_0_0_0_0, '0', blocks_add_xx_0, '2']
- [mimo_ofdm_jrc_Multi_targets_simulator_0_0_0_0, '1', blocks_add_xx_0_0, '3']
- [mimo_ofdm_jrc_matrix_transpose_0, '0', fft_vxx_0_1_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_radar_0, '0', virtual_sink_0_1_0_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', fft_vxx_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', mimo_ofdm_jrc_mimo_ofdm_radar_0, '1']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', fft_vxx_0_2_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', mimo_ofdm_jrc_mimo_ofdm_radar_0, '2']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', fft_vxx_0_2_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', mimo_ofdm_jrc_mimo_ofdm_radar_0, '3']
- [mimo_ofdm_jrc_ndp_generator_0, out, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0, '0', fft_vxx_0_0, '0']
- [mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0_0, '0', fft_vxx_0_0_0, '0']
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_ndp_generator_0, enable]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_socket_pdu_jrc_0, enable]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_0, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_2, stats]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [mimo_ofdm_jrc_stream_encoder_0, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_target_simulator_0, '0', blocks_add_xx_0, '0']
- [mimo_ofdm_jrc_target_simulator_0, '1', blocks_add_xx_0_0, '0']
- [mimo_ofdm_jrc_target_simulator_0_0, '0', blocks_add_xx_0, '1']
- [mimo_ofdm_jrc_target_simulator_0_0, '1', blocks_add_xx_0_0, '1']
- [mimo_ofdm_jrc_target_simulator_0_0_0, '0', blocks_add_xx_0, '3']
- [mimo_ofdm_jrc_target_simulator_0_0_0, '1', blocks_add_xx_0_0, '2']
- [mimo_ofdm_jrc_target_simulator_0_0_0_0, '0', blocks_add_xx_0, '2']
- [mimo_ofdm_jrc_target_simulator_0_0_0_0, '1', blocks_add_xx_0_0, '3']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_Multi_targets_simulator_0, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_target_simulator_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', mimo_ofdm_jrc_Multi_targets_simulator_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', mimo_ofdm_jrc_target_simulator_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', mimo_ofdm_jrc_Multi_targets_simulator_0_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', mimo_ofdm_jrc_target_simulator_0_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', mimo_ofdm_jrc_Multi_targets_simulator_0_0_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', mimo_ofdm_jrc_target_simulator_0_0_0_0, '0']
- [virtual_source_0_0, '0', fft_vxx_0_1, '0']
- [virtual_source_0_1, '0', blocks_throttle_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [virtual_source_0_1_0, '0', blocks_throttle_0_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0_1_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [virtual_source_0_1_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']

metadata:
  file_format: 1
