options:
  parameters:
    author: haocheng
    generate_options: qt_gui
    id: FMCW_Sim
    output_language: python
    title: FMCW_Simulation
  states: {}

blocks:
- name: SweepTime
  id: variable
  parameters:
    comment: FMCW sweep time, frequency=1/sweeptime
    value: '1e-5'
  states: {}
- name: Sweeptime
  id: variable_qtgui_range
  parameters:
    label: Sweep Time (s)
    orient: Qt.Horizontal
    start: '1e-6'
    step: '1e-6'
    stop: '1e-2'
    value: '1e-6'
  states: {state: disabled}
- name: USRP_frequency
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: amplitude
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    label: Delay Samples
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: 1/Sweeptime
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_samp
    minoutbuf: '24000'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/host-pc/O-JRC/examples/FMCW_Radar/GNU-Radio-Flowgraph/saved_data/saved_fmcw_io_sample_rx1.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/host-pc/O-JRC/examples/FMCW_Radar/GNU-Radio-Flowgraph/saved_data/saved_fmcw_io_sample_rx2.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/host-pc/O-JRC/examples/simulation/radar/fmcw_chirp.dat
    minoutbuf: '24000'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: N_head = T_capture * Fs
    minoutbuf: '24000'
    num_items: int(25e6)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: N_skip = T_stable * Fs
    minoutbuf: '24000'
    num_items: int(2.5e6)
    type: complex
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: amplitude
    comment: |-
      sensitivity=(2pi*bandwidth)/voltage range
      V_max = signal Amplitude
      V_min = V_max - offset
    minoutbuf: '24000'
    samp_rate: samp_rate
    sensitivity: bandwidth*cmath.pi*2
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6'
    comment: cutoff frequency = 2BR_max / c T_sweep
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '10'
    minoutbuf: '24000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: bandwidth
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"FFT"'
    type: complex
    update_time: '0.5'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Beat Signal (De-chirped)"'
    size: '128'
    srate: samp_rate
    type: complex
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"RX Signal"'
    size: '128'
    srate: samp_rate
    type: complex
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"TX1 Signal"'
    size: '512'
    srate: samp_rate
    type: complex
    update_time: '0.3'
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: USRP_frequency
    clock_source0: external
    dev_addr: '"addr0=192.168.101.2, master_clock_rate=250e6"'
    gain0: tx_gain
    minoutbuf: '24000'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"B:0"'
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: ''
    bw0: bandwidth
    center_freq0: USRP_frequency
    center_freq1: '0'
    clock_source0: external
    comment: |-
      uhd.tune_request(usrp_freq, rf_freq = usrp_freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
      recv_frame_size=65536,num_recv_frames=1024
    dc_offs_enb0: 'True'
    dc_offs_enb1: '""'
    dev_addr: '"addr=192.168.120.2,master_clock_rate=250e6"'
    gain0: rx_gain
    gain1: '0'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: '""'
    minoutbuf: '24000'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:0 B:0"'
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Saw Tooth
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_1, '0']
- [blocks_head_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_skiphead_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_vco_c_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vco_c_0, '0', uhd_usrp_sink_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
