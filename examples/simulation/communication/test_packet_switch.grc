options:
  parameters:
    generate_options: qt_gui
    id: test_packet_switch
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/xin/MIMO-OFDM-JRC-Optimal-Beam-and-Resource-Allocation/examples"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_0
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_1
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {state: disabled}
- name: mimo_ofdm_jrc_packet_control_0
  id: mimo_ofdm_jrc_packet_control
  parameters:
    packet_info_file: packet_data_file
    period_ms: '1000'
  states: {}
- name: mimo_ofdm_jrc_packet_switch_0
  id: mimo_ofdm_jrc_packet_switch
  parameters:
    packet_info_file: packet_data_file
    period_ms: '1000'
  states: {}
- name: mimo_ofdm_jrc_socket_pdu_jrc_0
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '200'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {state: disabled}
- name: mimo_ofdm_jrc_socket_pdu_jrc_1
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '10000'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {}

connections:
- [mimo_ofdm_jrc_ndp_generator_0, out, blocks_message_debug_0, print]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_ndp_generator_0, enable]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_socket_pdu_jrc_1, enable]
- [mimo_ofdm_jrc_socket_pdu_jrc_1, pdus, blocks_message_debug_0, print]

metadata:
  file_format: 1
