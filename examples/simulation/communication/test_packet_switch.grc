options:
  parameters:
    generate_options: qt_gui
    id: test_packet_switch
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/xin/MIMO-OFDM-JRC-Optimal-Beam-and-Resource-Allocation/examples"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.from_long(1) '
    period: '1000'
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_0
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_1
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {state: disabled}
- name: mimo_ofdm_jrc_packet_switch_0
  id: mimo_ofdm_jrc_packet_switch
  parameters:
    packet_info_file: /path/to/default/file
    period_ms: '1000'
  states: {}
- name: mimo_ofdm_jrc_socket_pdu_jrc_0
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '200'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {state: disabled}
- name: mimo_ofdm_jrc_socket_pdu_jrc_1
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '200'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {}

connections:
- [blocks_message_strobe_0, strobe, mimo_ofdm_jrc_ndp_generator_0, enable]
- [blocks_message_strobe_0, strobe, mimo_ofdm_jrc_socket_pdu_jrc_1, enable]
- [mimo_ofdm_jrc_ndp_generator_0, out, blocks_message_debug_0, print_pdu]
- [mimo_ofdm_jrc_ndp_generator_1, out, blocks_message_debug_0, print]
- [mimo_ofdm_jrc_packet_switch_0, Message Out, blocks_message_debug_0, print]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, blocks_message_debug_0, print]
- [mimo_ofdm_jrc_socket_pdu_jrc_1, pdus, blocks_message_debug_0, store]

metadata:
  file_format: 1
