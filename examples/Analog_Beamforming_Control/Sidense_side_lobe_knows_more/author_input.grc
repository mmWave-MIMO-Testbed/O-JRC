options:
  parameters:
    author: vuranlab
    generate_options: qt_gui
    id: author_code_try1
    output_language: python
    title: Author_code_try1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: 480e6
    fftsize: '1024'
    grid: 'True'
    label: Received Power (dBFull Scale)
    label1: '''Recieved Frequency'''
    name: '"Rx and Tx Frequency"'
    type: complex
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 500e3
    center_freq0: 480e6
    clock_source0: internal
    dev_addr: '"serial=32A0363"'
    gain0: '90'
    maxoutbuf: '10000'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
