options:
  parameters:
    author: host-pc
    generate_options: qt_gui
    id: V0_SISO_OFDM_RX
    output_language: python
    title: V0_SISO_OFDM_RX
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: ofdm_config_siso.N_ltf
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: ofdm_config_siso.N_tx
  states: {}
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Channel Estimation Algorithm
    labels: '["LS",  "STA"]'
    num_opts: '0'
    options: '[0,  1]'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: chan_est_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est_data.csv"
  states: {}
- name: chan_est_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est.csv"
  states: {}
- name: chan_est_ndp_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est_ndp.csv"
  states: {}
- name: comm_log_file
  id: variable
  parameters:
    value: parrent_path+"/data/comm_log.csv"
  states: {}
- name: corr_window_size
  id: variable
  parameters:
    value: int(fft_len/2)
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: ofdm_config_siso.N_sc
  states: {}
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/host-pc/O-JRC/examples"'
  states: {}
- name: radar_log_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_log.csv"
  states: {}
- name: radar_read_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_data.csv"
  states: {}
- name: rf_frequency
  id: variable
  parameters:
    value: usrp_freq+24.6e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,2
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(25e6)
  states: {}
- name: save_comm_log
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Save Comm Log
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: 4*(fft_len+cp_len)
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 4e8
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_frequency
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    minoutbuf: '24000'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters:
    minoutbuf: '24000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(fft_len/4)
    minoutbuf: '24000'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    affinity: '[2]'
    length: int(corr_window_size)+int(fft_len/4)
    max_iter: '16000'
    minoutbuf: '24000'
    scale: 1/1.5
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    minoutbuf: '24000'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '5000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Subtracting DC Offset
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(ofdm_config_siso.data_subcarriers)
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_len)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: ofdm_config_siso.l_ltf_fir
    type: ccc
  states: {state: disabled}
- name: mimo_ofdm_jrc_frame_detector_0
  id: mimo_ofdm_jrc_frame_detector
  parameters:
    affinity: '[3]'
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    ignore_gap: (len(ofdm_config_siso.l_stf_ltf_64)+N_tx)*(fft_len+cp_len)
    min_n_peaks: '30'
    minoutbuf: '48000'
    threshold: '0.85'
  states: {}
- name: mimo_ofdm_jrc_frame_sync_0
  id: mimo_ofdm_jrc_frame_sync
  parameters:
    cp_len: cp_len
    debug: 'False'
    fft_len: fft_len
    ltf_seq_time: ofdm_config_siso.l_ltf_fir
    sync_length: sync_length
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_0_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[0,40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Packet Error Rate"'
    time_window: '10'
    y_axis_lim: '[0,102]'
    y_label: '"PER [%]"'
    y_tag: '"per"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Received Data Throughput"'
    time_window: '10'
    y_axis_lim: '[0,5]'
    y_label: '"Throughput [KByte/s]"'
    y_tag: '"throughput"'
  states: {state: disabled}
- name: mimo_ofdm_jrc_mimo_ofdm_equalizer_0
  id: mimo_ofdm_jrc_mimo_ofdm_equalizer
  parameters:
    affinity: '[4]'
    bw: samp_rate
    chan_est_data_file: chan_est_data_file
    chan_est_file: chan_est_file
    chan_est_ndp_file: chan_est_ndp_file
    comm_log_file: comm_log_file
    cp_len: cp_len
    data_carriers: ofdm_config_siso.data_subcarriers
    debug: 'False'
    estimator: chan_est
    fft_len: fft_len
    freq: rf_frequency
    long_seq: ofdm_config_siso.l_stf_ltf_64[3]
    mapped_ltf_symbols: ofdm_config_siso.ltf_mapped_sc__ss_sym
    n_mimo_ltf: N_tx
    pilot_carriers: ofdm_config_siso.pilot_subcarriers
    pilot_symbols: ofdm_config_siso.pilot_symbols
    stats_record: 'False'
  states: {}
- name: mimo_ofdm_jrc_moving_avg_0
  id: mimo_ofdm_jrc_moving_avg
  parameters:
    affinity: '[0]'
    comment: Estimating DC Offset
    debug: 'False'
    length: '32'
    max_iter: '20000'
    minoutbuf: '24000'
    scale: 1/32
  states: {}
- name: mimo_ofdm_jrc_moving_avg_1
  id: mimo_ofdm_jrc_moving_avg
  parameters:
    affinity: '[1]'
    debug: 'False'
    length: '32'
    max_iter: '20000'
    minoutbuf: '24000'
    scale: '1'
  states: {}
- name: mimo_ofdm_jrc_stream_decoder_0
  id: mimo_ofdm_jrc_stream_decoder
  parameters:
    affinity: '[5]'
    debug: 'False'
    n_data_carriers: len(ofdm_config_siso.data_subcarriers)
    stats_path: comm_log_file
    stats_record: save_comm_log
  states: {}
- name: ofdm_config_siso
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 1
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: ofdm_config_siso_16sub
  id: epy_module
  parameters:
    source_code: "import numpy as np\n#import matplotlib.pyplot as plt\n\nN_tx = 1\nN_ltf = N_tx\nN_sc = 16  # 子载波数量\n\n# 重新定义数据子载波和导频子载波的索引\ndata_subcarriers = list(range(-7, -4)) + list(range(-3, 0)) + list(range(1, 4)) + list(range(5, 8))\npilot_subcarriers = [-4, 0, 4]  # 三个导频子载波\n\nN_data = len(data_subcarriers)\nN_pilot = len(pilot_subcarriers)\n\n# 重新定义导频符号序列\npilot_symbols = [(1, 1, 1), (1, 1, 1), (1, 1, 1), (1, 1, 1), \n                 (-1, -1, -1), (-1, -1, -1), (-1, -1, -1), (-1, -1, -1), \n                 (1, 1, 1), (1, 1, 1), (1, 1, 1), (1, 1, 1), \n                 (-1, -1, -1), (-1, -1, -1), (-1, -1, -1), (-1, -1, -1)]\n\n# 重新定义LTF和STF序列以匹配16个子载波\nl_stf_16_def = np.array([0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, (1.4719601443879746+1.4719601443879746j)])\nl_ltf_16_def = np.array([0, 0, 1, 1, -1, 1, 1, 1, -1, 1, -1, 1, 1, -1, -1, 0])\n\nl_ltf_16_custom = np.array([0, 1, 1, -1, 1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, 0])\n\nassert(len(l_stf_16_def) == N_sc)\nassert(len(l_ltf_16_def) == N_sc)\nassert(len(l_ltf_16_custom) == N_sc)\n\nsymbol_rotation = np.array([1, -1j, -1, 1j] * 4)\nl_ltf_16_rot = symbol_rotation*l_ltf_16_custom\nl_stf_ltf_16 = np.vstack((l_stf_16_def, l_stf_16_def, l_ltf_16_rot, l_ltf_16_custom))\n\nltf_16 = np.array([0, 1, 1, -1, 1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, 0], dtype=np.complex64)\nP_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)\n\nltf_tx = []\nfor i_tx in range(N_tx):\n    ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx, :N_ltf], ltf_16))))\n\nltf_mapped_16 = []\nfor i_tx in range(N_tx):\n    ltf_expand_time = np.outer(P_ltf[i_tx, :N_ltf], ltf_16)\n    ltf_mapped_16.append(ltf_expand_time.flatten().tolist())\n\nltf_mapped_16 = np.array(ltf_mapped_16)\n\nltf_mapped_sc__ss_sym = []\nfor i_sc in range(N_sc):\n    ltf_ss_sym = P_ltf[:N_tx, :N_ltf]*ltf_16[i_sc]\n    ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist())\n\nltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)\n\n# %%\nl_ltf = l_stf_ltf_16[3]\nl_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))\nl_ltf_fir = np.conj(l_ltf_time)\nl_ltf_fir = l_ltf_fir[::-1]\n\n#plt.figure()\n#plt.plot(np.abs(l_ltf_time))\n\n#plt.figure()\n#plt.plot(np.abs(np.convolve(l_ltf_fir, l_ltf_time, 'full')))\n\n"
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    grid: 'True'
    gui_hint: 4,2,1,2
    legend: 'False'
    name: CONSTELLATIONS
    size: ofdm_config_siso.N_data*5
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    alpha1: '0.7'
    bins: '100'
    color1: '"dark blue"'
    grid: 'True'
    legend: 'False'
    size: '100'
    type: float
    xmax: '100'
    xmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 10,0,1,4
    label1: ''
    label2: ''
    name: '"FRAME SYNC"'
    size: (fft_len+cp_len)*30
    srate: '1'
    tr_delay: '100'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,2,1,2
    label1: ''
    legend: 'False'
    name: '"FRAME SYNC CORR"'
    size: sync_length*2
    srate: '1'
    tr_delay: '100'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: float
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 3,2,1,2
    label1: ''
    label2: ''
    name: Signal RX
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '100'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    grid: 'True'
    gui_hint: 4,0,1,2
    label1: ''
    legend: 'False'
    name: '"PREAMBLE DETECTOR"'
    size: (fft_len+cp_len)*30
    srate: '1'
    tr_delay: '300'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: ''
    type: float
    update_time: '0.1'
    width1: '2'
    ymax: '2'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 5,0,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: '"FRAME"'
    size: (fft_len+cp_len)*30
    srate: '1'
    tr_delay: '300'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.8'
    autoscale: 'True'
    color1: dark blue
    entags: 'False'
    grid: 'True'
    legend: 'False'
    marker1: '0'
    name: Packet Error Rate
    size: '100'
    srate: '1'
    type: float
    update_time: '0.010'
    width1: '2'
    ylabel: Percentage
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: usrp_freq
    comment: |-
      uhd.tune_request(usrp_freq, rf_freq = usrp_freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
      recv_frame_size=65536,num_recv_frames=1024
    dc_offs_enb0: 'True'
    dev_addr: '"addr=192.168.122.2,master_clock_rate=250e6"'
    gain0: rx_gain
    iq_imbal_enb0: 'True'
    minoutbuf: '24000'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:0"'
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: FRAME
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: USRP
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: FRAME
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: USRP
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', mimo_ofdm_jrc_frame_sync_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', mimo_ofdm_jrc_frame_detector_0, '0']
- [blocks_divide_xx_0, '0', mimo_ofdm_jrc_frame_detector_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_xx_0, '0', mimo_ofdm_jrc_moving_avg_1, '0']
- [blocks_null_source_0, '0', blocks_sub_xx_0, '0']
- [blocks_null_source_0, '0', mimo_ofdm_jrc_moving_avg_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [fft_vxx_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0']
- [interp_fir_filter_xxx_0_1, '0', blocks_complex_to_mag_1, '0']
- [mimo_ofdm_jrc_frame_detector_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [mimo_ofdm_jrc_frame_detector_0, '0', virtual_sink_0_0_0, '0']
- [mimo_ofdm_jrc_frame_sync_0, '0', blocks_stream_to_vector_0, '0']
- [mimo_ofdm_jrc_frame_sync_0, '0', qtgui_time_sink_x_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', blocks_vector_to_stream_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', mimo_ofdm_jrc_stream_decoder_0, '0']
- [mimo_ofdm_jrc_moving_avg_0, '0', blocks_sub_xx_0, '1']
- [mimo_ofdm_jrc_moving_avg_1, '0', blocks_complex_to_mag_0, '0']
- [mimo_ofdm_jrc_moving_avg_1, '0', mimo_ofdm_jrc_frame_detector_0, '1']
- [mimo_ofdm_jrc_stream_decoder_0, '0', blocks_null_sink_0, '0']
- [mimo_ofdm_jrc_stream_decoder_0, '0', qtgui_time_sink_x_1, '0']
- [mimo_ofdm_jrc_stream_decoder_0, stats, mimo_ofdm_jrc_gui_time_plot_0_0, stats]
- [mimo_ofdm_jrc_stream_decoder_0, stats, mimo_ofdm_jrc_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_stream_decoder_0, stats, mimo_ofdm_jrc_gui_time_plot_1_0, stats]
- [mimo_ofdm_jrc_stream_decoder_0, sym, blocks_socket_pdu_1, pdus]
- [uhd_usrp_source_0, '0', blocks_sub_xx_0, '0']
- [uhd_usrp_source_0, '0', mimo_ofdm_jrc_moving_avg_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0_1_1, '0']
- [virtual_source_0_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0, '0', interp_fir_filter_xxx_0_1, '0']
- [virtual_source_0_0, '0', mimo_ofdm_jrc_frame_sync_0, '0']
- [virtual_source_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
