options:
  parameters:
    author: Haocheng Zhu, Ceyhun D. Ozkaptan
    category: Custom
    description: The Ohio State University
    generate_options: qt_gui
    id: V0_comm_autoMCS_MIMO_TX
    output_language: python
    realtime_scheduling: '1'
    title: MIMO OFDM Comm Transceiver
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: ofdm_config.N_ltf
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: ofdm_config.N_tx
  states: {}
- name: amp_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    label: '''TX2 \n Amp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.64'
  states: {}
- name: amp_tx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,4,1,2
    label: '''TX3 \n Amp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.58'
  states: {}
- name: amp_tx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,6,1,2
    label: '''TX4 \n Amp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.76'
  states: {}
- name: chan_est_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est.csv"
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    comment: 125 MHz -> 187
    gui_hint: 8,0,1,8
    label: TX/RX Sync
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '500'
    value: 187+5
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: ofdm_config.N_sc
  states: {}
- name: freq_smoothing
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,4,1,2
    label: '''Frequency    \nSmoothing'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: interp_factor_angle
  id: variable
  parameters:
    value: '16'
  states: {}
- name: mcs
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,1
    label: Modulation and Coding Scheme
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2","16QAM 3/4" , "ReadFile"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6] '
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: mcs_ctrl_file
  id: variable
  parameters:
    value: parrent_path+"/data/mcs_ctrl.csv"
  states: {}
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/host-pc/O-JRC/examples"'
  states: {}
- name: phase_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,2,1,2
    label: '''TX2 \n Phase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '-1.06'
  states: {}
- name: phase_tx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,4,1,2
    label: '''TX3 \n Phase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '2.08'
  states: {}
- name: phase_tx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,6,1,2
    label: '''TX4 \n Phase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '2.35'
  states: {}
- name: phased_steering
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 20,0,1,4
    label: '''Phased Steering'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: radar_aided
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,2,1,2
    label: '''Radar-aided   \nPrecoding'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: radar_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_data.csv"
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: usrp_freq+20e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '41'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: target_OFDM_symbols
  id: variable
  parameters:
    comment: |-
      fix OFDM symbols per packet.
      >0 enable，according to MCS to cut or adding 0;
      ==0 for fixed packet data payload length
    value: '0'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '42'
  states: {}
- name: tx_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,2
    label: TX Scaling
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '4'
    value: '0.42'
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_freq
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx2*cmath.exp(1j*phase_tx2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx3*cmath.exp(1j*phase_tx3)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx4*cmath.exp(1j*phase_tx4)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '5000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_1
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_3
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: mimo_ofdm_jrc_mimo_precoder_0
  id: mimo_ofdm_jrc_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    affinity: '[7]'
    chan_est_file: chan_est_file
    chan_est_smoothing: freq_smoothing
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: '1000'
    phased_steering: 'False'
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: radar_aided
    radar_log_file: radar_data_file
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: 'False'
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_0
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {state: disabled}
- name: mimo_ofdm_jrc_packet_switch_0
  id: mimo_ofdm_jrc_packet_switch
  parameters:
    packet_info_file: packet_data_file
    period_ms: '100'
  states: {state: disabled}
- name: mimo_ofdm_jrc_socket_pdu_jrc_0
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '5000'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {state: disabled}
- name: mimo_ofdm_jrc_stream_encoder_0
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mod_encode: mcs
  states: {state: disabled}
- name: mimo_ofdm_jrc_stream_encoder_automodulation_0
  id: mimo_ofdm_jrc_stream_encoder_automodulation
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mcs_ctrl_file: mcs_ctrl_file
    mod_encode: mcs
    target_nsym: target_OFDM_symbols
  states: {}
- name: mimo_ofdm_jrc_usrp_mimo_trx_0
  id: mimo_ofdm_jrc_usrp_mimo_trx
  parameters:
    N_mboard: '2'
    N_rx: '1'
    N_tx: '4'
    affinity: '[6]'
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX,TX/RX,TX/RX"'
    args: '"addr0=192.168.120.2, addr1=192.168.101.2, master_clock_rate=250e6"'
    center_freq: usrp_freq
    clock_sources: '"external,external"'
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    num_delay_samps: delay_samp
    samp_rate: samp_rate
    time_sources: '"external,external"'
    timeout_rx: '0.6'
    timeout_tx: '0.6'
    update_period: '0.04'
    wait_rx: '0.01'
    wait_tx: '0.01'
    wire_rx: '""'
    wire_tx: '""'
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 100*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 100*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 100*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 100*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: ofdm_config
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 4
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: TX4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX4
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', mimo_ofdm_jrc_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_automodulation_0, pdu_in]
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', virtual_sink_0_1, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0, '0', virtual_sink_0_1_0, '0']
- [digital_ofdm_cyclic_prefixer_0_1, '0', virtual_sink_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_2, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_2_0, '0', digital_ofdm_cyclic_prefixer_0_0_0, '0']
- [fft_vxx_0_3, '0', digital_ofdm_cyclic_prefixer_0_1, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', fft_vxx_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', fft_vxx_0_3, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', fft_vxx_0_2_0, '0']
- [mimo_ofdm_jrc_ndp_generator_0, out, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [mimo_ofdm_jrc_ndp_generator_0, out, mimo_ofdm_jrc_stream_encoder_automodulation_0, pdu_in]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_ndp_generator_0, enable]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_socket_pdu_jrc_0, enable]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, mimo_ofdm_jrc_stream_encoder_automodulation_0, pdu_in]
- [mimo_ofdm_jrc_stream_encoder_0, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_stream_encoder_automodulation_0, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '0', blocks_null_sink_0, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '1']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '2']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '3']
- [virtual_source_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0_1_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [virtual_source_0_1_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']

metadata:
  file_format: 1
