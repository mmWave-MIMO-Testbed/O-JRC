options:
  parameters:
    author: Ceyhun D. Ozkaptan
    generate_options: qt_gui
    id: mimo_usrp_alignment
    output_language: python
    title: 'MIMO USRP Alignment '
  states: {}

blocks:
- name: amp_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,3
    label: RX2 - Amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: amp_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,2
    label: TX2 - Amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: amp_tx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    label: TX3 - Amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: amp_tx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,4,1,2
    label: TX4 - Amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    label: TX/RX Delay [Samples]
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '400'
    value: '100'
  states: {}
- name: fft_interp
  id: variable
  parameters:
    value: '8'
  states: {}
- name: n_samples
  id: variable
  parameters:
    value: int(samp_rate/sine_freq)*4
  states: {}
- name: phase_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,3,1,3
    label: 'RX2 - Phase '
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '0'
  states: {}
- name: phase_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,2
    label: 'TX2 - Phase '
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '0'
  states: {}
- name: phase_tx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,2,1,2
    label: 'TX3 - Phase '
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '0'
  states: {}
- name: phase_tx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,4,1,2
    label: 'TX4 - Phase '
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: sine_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '1'
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: sine_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: 1/100
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: 1/100
    type: float
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_rx2*cmath.exp(1j*phase_rx2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx2*cmath.exp(1j*phase_tx2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx3*cmath.exp(1j*phase_tx3)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx4*cmath.exp(1j*phase_tx4)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: n_samples
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: foo_pad_tagged_stream_0
  id: foo_pad_tagged_stream
  parameters:
    buffer_size: n_samples*fft_interp
    len_tag_name: ' "packet_len"'
    minoutbuf: n_samples*fft_interp*2
  states: {}
- name: foo_pad_tagged_stream_0_0
  id: foo_pad_tagged_stream
  parameters:
    buffer_size: n_samples*fft_interp
    len_tag_name: ' "packet_len"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: mimo_ofdm_jrc_fft_peak_detect_0
  id: mimo_ofdm_jrc_fft_peak_detect
  parameters:
    cut_max_freq: 'False'
    interp_factor: '1.0'
    len_key: '"packet_len"'
    max_freq: '[1,1]'
    samp_protect: '0'
    samp_rate: samp_rate
    threshold: '-120'
  states: {}
- name: mimo_ofdm_jrc_fft_peak_detect_0_0
  id: mimo_ofdm_jrc_fft_peak_detect
  parameters:
    cut_max_freq: 'False'
    interp_factor: '1.0'
    len_key: '"packet_len"'
    max_freq: '[1,1]'
    samp_protect: '0'
    samp_rate: samp_rate
    threshold: '-120'
  states: {}
- name: mimo_ofdm_jrc_usrp_mimo_trx_0
  id: mimo_ofdm_jrc_usrp_mimo_trx
  parameters:
    N_mboard: '2'
    N_rx: '2'
    N_tx: '4'
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX,TX/RX,TX/RX"'
    args: '"addr0=192.168.120.2, addr1=192.168.101.2, master_clock_rate=250e6"'
    center_freq: usrp_freq
    clock_sources: '"external,external"'
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    num_delay_samps: delay_samp
    samp_rate: samp_rate
    time_sources: '"external,external"'
    timeout_rx: '0.5'
    timeout_tx: '0.5'
    update_period: '0.05'
    wait_rx: '0.01'
    wait_tx: '0.01'
    wire_rx: '""'
    wire_tx: '""'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 8,4,1,2
    label1: RX1
    max: 10e6
    min: '0'
    name: '"Phase - RX1"'
    type: float
    unit1: rad
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 8,2,1,2
    label1: RX1
    max: 10e6
    min: '0'
    name: '"Magnitude - RX1"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 9,2,1,2
    label1: Mag - RX2
    max: 10e6
    min: '0'
    name: '"Magnitude - RX2"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 9,4,1,2
    label1: Phase - RX2
    max: 10e6
    min: '0'
    name: '"Phase - RX2"'
    type: float
    unit1: rad
  states: {}
- name: qtgui_number_sink_0_0_0_1_0
  id: qtgui_number_sink
  parameters:
    avg: '0.5'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,2,1,2
    label1: RX1/RX2
    max: 10e6
    min: '0'
    name: '"Magnitude Ratio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_1_0
  id: qtgui_number_sink
  parameters:
    avg: '0.5'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,4,1,2
    label1: RX1-RX2
    max: 10e6
    min: '0'
    name: '"Phase Difference"'
    type: float
    unit1: rad
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 8,0,1,2
    label1: ''' '''
    max: 10e6
    min: '0'
    name: '"Frequency - RX1"'
    type: float
    unit1: Hz
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 9,0,1,2
    label1: Frequency - RX2
    max: 10e6
    min: '0'
    name: Frequency - RX2
    type: float
    unit1: Hz
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,0,1,2
    label1: RX1-RX2
    max: 10e6
    min: '0'
    name: '"Freq Difference"'
    type: float
    unit1: Hz
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 3,0,1,6
    label1: RX1
    label2: RX2
    name: '"REAL"'
    nconnections: '2'
    size: n_samples
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,0,1,6
    label1: RX1
    label2: RX2
    name: '"IMAG"'
    nconnections: '2'
    size: n_samples
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    width1: '2'
    width2: '2.0'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    autoscale: 'True'
    grid: 'True'
    name: '"FFT - RX1"'
    size: int(n_samples*fft_interp/64)
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    width1: '2'
    ylabel: Magnitude
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    autoscale: 'True'
    grid: 'True'
    name: '"FFT - RX2"'
    size: int(n_samples*fft_interp/64)
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    width1: '2'
    ylabel: Magnitude
  states: {}
- name: radar_ts_fft_cc_0_2
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: n_samples*fft_interp
    packet_len: n_samples*fft_interp
  states: {}
- name: radar_ts_fft_cc_0_2_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: n_samples*fft_interp
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_imag_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_divide_xx_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_divide_xx_0, '0', qtgui_number_sink_0_0_0_1_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0_0_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0_0_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '3']
- [blocks_stream_to_tagged_stream_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '0']
- [blocks_sub_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_number_sink_0_0_1_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_number_sink_0_2, '0']
- [foo_pad_tagged_stream_0, '0', radar_ts_fft_cc_0_2, '0']
- [foo_pad_tagged_stream_0_0, '0', radar_ts_fft_cc_0_2_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0, '0', blocks_sub_xx_0_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0, '0', qtgui_number_sink_0_1, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0, '1', blocks_sub_xx_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0, '1', qtgui_number_sink_0_0_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0, '2', blocks_divide_xx_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0, '2', qtgui_number_sink_0_0_0_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0_0, '0', blocks_sub_xx_0_0, '1']
- [mimo_ofdm_jrc_fft_peak_detect_0_0, '0', qtgui_number_sink_0_1_0, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0_0, '1', blocks_sub_xx_0, '1']
- [mimo_ofdm_jrc_fft_peak_detect_0_0, '1', qtgui_number_sink_0_0_0_1, '0']
- [mimo_ofdm_jrc_fft_peak_detect_0_0, '2', blocks_divide_xx_0, '1']
- [mimo_ofdm_jrc_fft_peak_detect_0_0, '2', qtgui_number_sink_0_0_0_0_0, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '0', blocks_complex_to_imag_0_0, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '0', blocks_complex_to_real_0, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '0', virtual_sink_0, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '1', blocks_multiply_const_vxx_0, '0']
- [radar_ts_fft_cc_0_2, '0', blocks_complex_to_mag_0_0, '0']
- [radar_ts_fft_cc_0_2, '0', mimo_ofdm_jrc_fft_peak_detect_0, '0']
- [radar_ts_fft_cc_0_2_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [radar_ts_fft_cc_0_2_0, '0', mimo_ofdm_jrc_fft_peak_detect_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0, '0', foo_pad_tagged_stream_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_0_0, '0', foo_pad_tagged_stream_0_0, '0']

metadata:
  file_format: 1
