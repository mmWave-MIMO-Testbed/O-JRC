options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Sivers_Radar_Sim
    output_language: python
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: preamble_designer_SISO.N_ltf
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '1'
  states: {}
- name: N_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: preamble_designer_SISO.N_tx
  states: {}
- name: R_max
  id: variable
  parameters:
    value: 3e8*fft_len/(2*samp_rate)
  states: {}
- name: R_res
  id: variable
  parameters:
    value: 3e8/(2*samp_rate)
  states: {}
- name: TX1_RXs
  id: variable
  parameters:
    value: '[1*wavelength, 3*wavelength]'
  states: {}
- name: angle_axis
  id: variable
  parameters:
    value: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
  states: {}
- name: angle_max
  id: variable
  parameters:
    value: np.rad2deg(np.arcsin((N_tx*N_rx*interp_factor-5)/(N_tx*N_rx*interp_factor)))
  states: {}
- name: capture_radar
  id: variable_qtgui_push_button
  parameters:
    label: 'Capture Radar Image '
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: chan_est_path
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est.csv"
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: data_carriers_64
  id: variable
  parameters:
    value: list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
  states: {}
- name: digital_beamforming
  id: variable_qtgui_chooser
  parameters:
    label: Digital Beamforming
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: int(2**6)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4e8
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: interp_factor_angle
  id: variable
  parameters:
    value: '16'
  states: {}
- name: max_ofdm_symbols
  id: variable
  parameters:
    value: '800'
  states: {}
- name: mcs
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,1
    label: Modulation and Coding Scheme
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2","16QAM 3/4" ]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5] '
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: noise_figure_dB
  id: variable_qtgui_range
  parameters:
    label: Noise Figure (dB)
    orient: Qt.Horizontal
    start: '1'
    step: '0.1'
    stop: '40'
    value: '10'
  states: {}
- name: noise_var
  id: variable
  parameters:
    value: 4.003886160000000e-21*samp_rate*10**(noise_figure_dB/10.0)
  states: {}
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/host-pc/O-JRC/examples"'
  states: {}
- name: pilot_carriers_64
  id: variable
  parameters:
    comment: range(-16,0) + range(1,17)
    value: (-21, -7, 7, 21)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))
  states: {}
- name: radar_chan_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_chan.csv"
  states: {}
- name: radar_log_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_log.csv"
  states: {}
- name: range_axis
  id: variable
  parameters:
    comment: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    value: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 25e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: save_radar_log
  id: variable_qtgui_chooser
  parameters:
    label: Save Radar Log
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: sync_words
  id: variable
  parameters:
    value: ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))
  states: {}
- name: trgt_angle
  id: variable_qtgui_range
  parameters:
    label: Target's Angle
    orient: Qt.Horizontal
    rangeType: int
    start: '-89'
    step: '1'
    stop: '+89'
    value: '0'
  states: {}
- name: trgt_range
  id: variable_qtgui_range
  parameters:
    label: Target's Distance
    orient: Qt.Horizontal
    start: '0.1'
    step: '1'
    stop: R_max
    value: '10'
  states: {}
- name: trgt_rcs_dbsm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: trgt_velocity
  id: variable_qtgui_range
  parameters:
    label: Velocity
    orient: Qt.Horizontal
    start: '-40'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: tx_multiplier
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '0.05'
    step: '0.05'
    stop: '10'
    value: '0.1'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_freq
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(noise_var)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    affinity: '0'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: parrent_path+"/data/static_radar_image.csv"
    type: float
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {state: bypassed}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: max_ofdm_symbols
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    comment: |-
      window.hanning(fft_len*interp_factor)
      window.rectangular(fft_len*interp_factor)
    fft_size: fft_len*interp_factor
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_len*interp_factor)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    comment: |-
      window.hanning(N_tx*N_rx*interp_factor)
      window.rectangular(N_tx*N_rx*interp_factor)
    fft_size: N_tx*N_rx*interp_factor_angle
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N_tx*N_rx*interp_factor_angle)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: mimo_ofdm_jrc_gui_heatmap_plot_0
  id: mimo_ofdm_jrc_gui_heatmap_plot
  parameters:
    autoscale_z: 'True'
    axis_x: angle_axis
    axis_y: range_axis
    db_scale: 'False'
    digital_control: digital_beamforming
    dynamic_range_db: '15'
    interval: '100'
    label: Range-Angle Image
    len_key: '"packet_len"'
    sivers_angle_log: ''
    vlen: N_tx*N_rx*interp_factor_angle
    x_axis_ticks: '[-90, 90, 10]'
    xlabel: '"Angle"'
    y_axis_ticks: '[0, 32, 4]'
    ylabel: '"Range (m)"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[0,40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Angle Estimate"'
    time_window: '10'
    y_axis_lim: '[-70,70]'
    y_label: '"Angle (degree)"'
    y_tag: '"angle"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_2
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Range Estimate"'
    time_window: '10'
    y_axis_lim: '[0,20]'
    y_label: '"Range (m)"'
    y_tag: '"range"'
  states: {}
- name: mimo_ofdm_jrc_matrix_transpose_0
  id: mimo_ofdm_jrc_matrix_transpose
  parameters:
    debug: 'False'
    input_len: fft_len*interp_factor
    interp_factor: interp_factor_angle
    len_key: '"packet_len"'
    minoutbuf: '65535'
    output_len: N_tx*N_rx
  states: {}
- name: mimo_ofdm_jrc_mimo_ofdm_radar_0
  id: mimo_ofdm_jrc_mimo_ofdm_radar
  parameters:
    N_pre: len(preamble_designer_SISO.l_stf_ltf_64)+1
    N_rx: N_rx
    N_sym: N_tx
    N_tx: N_tx
    background_record: 'False'
    background_removal: 'False'
    capture_sig: capture_radar
    debug: 'False'
    enable_tx_interleave: 'False'
    fft_len: fft_len
    interp_factor: interp_factor
    len_tag_key: '"packet_len"'
    radar_chan_file: radar_chan_file
    record_len: '8'
    stats_record: 'False'
  states: {}
- name: mimo_ofdm_jrc_mimo_precoder_0
  id: mimo_ofdm_jrc_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    chan_est_file: ''''''
    chan_est_smoothing: 'True'
    data_carriers: data_carriers_64
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: preamble_designer_SISO.ltf_mapped_sc__ss_sym
    minoutbuf: max_ofdm_symbols
    phased_steering: 'False'
    pilot_carriers: pilot_carriers_64
    pilot_symbols: pilot_symbols
    radar_aided: 'False'
    radar_log_file: ''''''
    sync_words: preamble_designer_SISO.l_stf_ltf_64
    use_radar_streams: 'False'
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_0
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {}
- name: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0
  id: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {}
- name: mimo_ofdm_jrc_packet_switch_0
  id: mimo_ofdm_jrc_packet_switch
  parameters:
    packet_info_file: packet_data_file
    period_ms: '50'
  states: {}
- name: mimo_ofdm_jrc_range_angle_estimator_0
  id: mimo_ofdm_jrc_range_angle_estimator
  parameters:
    angle_bins: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
    debug: 'False'
    len_key: '"packet_len"'
    noise_discard_angle: '10'
    noise_discard_range: R_res*2
    power_threshold: '0'
    range_bins: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    snr_threshold: '15'
    stats_path: radar_log_file
    stats_record: save_radar_log
    stats_signal_strength_path: '""'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: mimo_ofdm_jrc_socket_pdu_jrc_0
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '10000'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: mimo_ofdm_jrc_stream_encoder_1
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mod_encode: mcs
  states: {}
- name: mimo_ofdm_jrc_target_simulator_0
  id: mimo_ofdm_jrc_target_simulator
  parameters:
    azimuth: trgt_angle
    center_freq: rf_freq
    debug: 'False'
    len_key: '"packet_len"'
    minoutbuf: max_ofdm_symbols*(fft_len+cp_len)
    position_rx: TX1_RXs
    range: trgt_range
    rcs: 10**(trgt_rcs_dbsm/10.0)
    rndm_phaseshift: 'False'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-40'
    velocity: trgt_velocity
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 500*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: ofdm_config
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 4
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)

      # l_stf_ltf_128_custom = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, (-0-1j), (-0-1j), -1j, -1j, 1j, (-0-1j), -1j, 1j, 1j, (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), (-0-1j), 1j, 1j, 1j, 1j, 1j, -1j, 1j, (-0-1j), 1j, -1j, (-0-1j), 1j, 1j, -1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), 1j, -1j, 1j, (-0-1j), (-0-1j), 1j, 1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), 1j, 0, (-1-0j), -1, (-1+0j), 1, (1+0j), 1, (-1+0j), -1, (1+0j), 1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), 1, (1+0j), -1, (-1+0j), 1, (1+0j), 1, (1+0j), 1, (-1-0j), 1, (-1+0j), 1, (-1-0j), -1, (1+0j), 1, (-1-0j), -1, (-1+0j), -1, (-1-0j), -1, (1+0j), -1, (1+0j), -1, (-1+0j), 1, (1+0j), -1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), -1, (-1-0j), -1, 0j), 
      #     (0, 0, 1j, -1, -1j, 1, -1j, -1, -1j, -1, -1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, 1, 0, -1j, 1, 1j, 1, 1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, -1j, 1, -1j, 1, -1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, -1j, 1, 0))

      # l_stf_ltf_64 = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0),
      #  (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), 
      #     (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      # ltf_mapped_64 = np.array(ltf_mapped_64).T
      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: preamble_designer_SISO
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 1
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)

      # l_stf_ltf_128_custom = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, (-0-1j), (-0-1j), -1j, -1j, 1j, (-0-1j), -1j, 1j, 1j, (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), (-0-1j), 1j, 1j, 1j, 1j, 1j, -1j, 1j, (-0-1j), 1j, -1j, (-0-1j), 1j, 1j, -1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), 1j, -1j, 1j, (-0-1j), (-0-1j), 1j, 1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), 1j, 0, (-1-0j), -1, (-1+0j), 1, (1+0j), 1, (-1+0j), -1, (1+0j), 1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), 1, (1+0j), -1, (-1+0j), 1, (1+0j), 1, (1+0j), 1, (-1-0j), 1, (-1+0j), 1, (-1-0j), -1, (1+0j), 1, (-1-0j), -1, (-1+0j), -1, (-1-0j), -1, (1+0j), -1, (1+0j), -1, (-1+0j), 1, (1+0j), -1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), -1, (-1-0j), -1, 0j), 
      #     (0, 0, 1j, -1, -1j, 1, -1j, -1, -1j, -1, -1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, 1, 0, -1j, 1, 1j, 1, 1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, -1j, 1, -1j, 1, -1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, -1j, 1, 0))

      # l_stf_ltf_64 = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0),
      #  (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), 
      #     (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      # ltf_mapped_64 = np.array(ltf_mapped_64).T
      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: Signal IDFT
    size: '512'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RANGE-ANGLE
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RANGE-ANGLE
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0_1_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', mimo_ofdm_jrc_zero_pad_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', mimo_ofdm_jrc_gui_heatmap_plot_0, '0']
- [blocks_throttle_0, '0', mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0, '0']
- [blocks_vector_to_stream_1_0, '0', qtgui_time_sink_x_0_0_0_0_0_1, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '1']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_1_0, '0']
- [fft_vxx_0_1, '0', mimo_ofdm_jrc_matrix_transpose_0, '0']
- [fft_vxx_0_1_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_1_0, '0', mimo_ofdm_jrc_range_angle_estimator_0, '0']
- [mimo_ofdm_jrc_matrix_transpose_0, '0', fft_vxx_0_1_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_radar_0, '0', virtual_sink_0_1_0_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', fft_vxx_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '0']
- [mimo_ofdm_jrc_ndp_generator_0, out, mimo_ofdm_jrc_stream_encoder_1, pdu_in]
- [mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0, '0', fft_vxx_0_0, '0']
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_ndp_generator_0, enable]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_socket_pdu_jrc_0, enable]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_0, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_2, stats]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, mimo_ofdm_jrc_stream_encoder_1, pdu_in]
- [mimo_ofdm_jrc_stream_encoder_1, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_target_simulator_0, '0', blocks_add_xx_0, '0']
- [mimo_ofdm_jrc_target_simulator_0, '1', blocks_null_sink_1, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_target_simulator_0, '0']
- [virtual_source_0_0, '0', fft_vxx_0_1, '0']
- [virtual_source_0_1, '0', blocks_throttle_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
