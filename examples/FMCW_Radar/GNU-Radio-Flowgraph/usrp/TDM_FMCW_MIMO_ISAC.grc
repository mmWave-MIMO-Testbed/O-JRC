options:
  parameters:
    author: haocheng
    generate_options: qt_gui
    id: TDM_FMCW_MIMO_ISAC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N_USRP
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: USRP_frequency
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    comment: 125 MHz -> 187
    gui_hint: 8,0,1,8
    label: TX/RX Sync
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '500'
    value: 187+5
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: FMCW_MIMO_FMCW_MIMO_USRP_0
  id: FMCW_MIMO_FMCW_MIMO_USRP
  parameters:
    N_mboard: N_USRP
    N_rx: N_rx
    N_tx: N_tx
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX"'
    args: '"addr0=192.168.1xx.2, addr1=192.168.1xx.2, master_clock_rate=xxxe6"'
    center_freq: USRP_frequency
    clock_sources: '"external,external"'
    debug: 'False'
    gain_rx: ''
    gain_tx: ''
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    num_delay_samps: delay_samp
    samp_rate: samp_rate
    time_sources: '"external,external"'
    timeout_rx: '0.5'
    timeout_tx: '0.5'
    update_period: ''
    wait_rx: '0.01'
    wait_tx: '0.01'
    wire_rx: '""'
    wire_tx: '""'
  states: {}
- name: FMCW_MIMO_TDM_FMCW_Generator_0
  id: FMCW_MIMO_TDM_FMCW_Generator
  parameters:
    bandwidth: 125e6
    chirp_duration: '0.001'
    enabled: 'True'
    num_tx: '4'
    samp_rate: 125e6
    tdm_offset: '0.005'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/haocheng/O-JRC/examples/FMCW_Radar/GNU-Radio-Flowgraph/saved_data/saved_fmcw_io_sample_rx1.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/haocheng/O-JRC/examples/FMCW_Radar/GNU-Radio-Flowgraph/saved_data/saved_fmcw_io_sample_rx2.dat
    type: complex
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}

connections:
- [FMCW_MIMO_FMCW_MIMO_USRP_0, '0', blocks_file_sink_0, '0']
- [FMCW_MIMO_FMCW_MIMO_USRP_0, '1', blocks_file_sink_0_0, '0']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '0', FMCW_MIMO_FMCW_MIMO_USRP_0, '0']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '1', FMCW_MIMO_FMCW_MIMO_USRP_0, '1']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '2', FMCW_MIMO_FMCW_MIMO_USRP_0, '2']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '3', FMCW_MIMO_FMCW_MIMO_USRP_0, '3']

metadata:
  file_format: 1
