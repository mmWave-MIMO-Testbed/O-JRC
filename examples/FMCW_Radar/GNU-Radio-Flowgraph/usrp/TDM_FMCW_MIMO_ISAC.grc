options:
  parameters:
    author: haocheng
    generate_options: qt_gui
    id: TDM_FMCW_MIMO_ISAC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FMCW_Generation
  id: variable_qtgui_chooser
  parameters:
    label: FMCW_Generation)Switch
    label0: 'On'
    label1: 'OFF'
    num_opts: '2'
    option0: 'True'
    option1: 'False'
    type: raw
    value: 'True'
  states: {}
- name: N_USRP
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: USRP_frequency
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: chirp_duration
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    comment: 125 MHz -> 187
    gui_hint: 8,0,1,8
    label: TX/RX Sync
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '500'
    value: 187+5
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '41'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '42'
  states: {}
- name: FMCW_MIMO_FMCW_MIMO_USRP_0
  id: FMCW_MIMO_FMCW_MIMO_USRP
  parameters:
    N_mboard: N_USRP
    N_rx: N_rx
    N_tx: N_tx
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX,TX/RX,TX/RX"'
    args: '"addr0=192.168.120.2, addr1=192.168.101.2, master_clock_rate=250e6"'
    center_freq: USRP_frequency
    clock_sources: '"external,external"'
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    num_delay_samps: delay_samp
    samp_rate: samp_rate
    time_sources: '"external,external"'
    timeout_rx: '0.5'
    timeout_tx: '0.5'
    update_period: '0.04'
    wait_rx: '0.01'
    wait_tx: '0.01'
    wire_rx: '""'
    wire_tx: '""'
  states: {}
- name: FMCW_MIMO_TDM_FMCW_Generator_0
  id: FMCW_MIMO_TDM_FMCW_Generator
  parameters:
    bandwidth: bandwidth
    chirp_duration: chirp_duration
    enabled: FMCW_Generation
    len_key: '"packet_len"'
    num_tx: N_tx
    samp_rate: samp_rate
    tdm_offset: '0.01'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/host-pc/O-JRC/examples/FMCW_Radar/GNU-Radio-Flowgraph/saved_data/saved_fmcw_io_sample_rx1.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/host-pc/O-JRC/examples/FMCW_Radar/GNU-Radio-Flowgraph/saved_data/saved_fmcw_io_sample_rx2.dat
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: bandwidth
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"FFT"'
    type: complex
    update_time: '0.5'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [FMCW_MIMO_FMCW_MIMO_USRP_0, '0', blocks_file_sink_0, '0']
- [FMCW_MIMO_FMCW_MIMO_USRP_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [FMCW_MIMO_FMCW_MIMO_USRP_0, '1', blocks_file_sink_0_0, '0']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '0', FMCW_MIMO_FMCW_MIMO_USRP_0, '0']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '1', FMCW_MIMO_FMCW_MIMO_USRP_0, '1']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '2', FMCW_MIMO_FMCW_MIMO_USRP_0, '2']
- [FMCW_MIMO_TDM_FMCW_Generator_0, '3', FMCW_MIMO_FMCW_MIMO_USRP_0, '3']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
