options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: mimo_ofdm_joint_TRX
    output_language: python
    realtime_scheduling: '1'
    title: MIMO OFDM JRC Transceiver
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: ofdm_config.N_ltf
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '2'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: ofdm_config.N_tx
  states: {}
- name: R_max
  id: variable
  parameters:
    value: 3e8*fft_len/(2*samp_rate)
  states: {}
- name: R_res
  id: variable
  parameters:
    value: 3e8/(2*samp_rate)
  states: {}
- name: amp_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,2
    label: '''RX2 \nAmp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1.12'
  states: {}
- name: amp_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    label: '''TX2 \n Amp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.9'
  states: {}
- name: amp_tx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,4,1,2
    label: '''TX3 \n Amp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.9'
  states: {}
- name: amp_tx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,6,1,2
    label: '''TX4 \n Amp'''
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.9'
  states: {}
- name: angle_axis
  id: variable
  parameters:
    value: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
  states: {}
- name: angle_max
  id: variable
  parameters:
    value: np.rad2deg(np.arcsin((N_tx*N_rx*interp_factor-5)/(N_tx*N_rx*interp_factor)))
  states: {}
- name: angle_res
  id: variable
  parameters:
    value: np.rad2deg(np.arcsin(2/(N_tx*N_rx)))
  states: {}
- name: background_record
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,2
    label: '''Static Background    \nRecording'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: int
    value: 'True'
  states: {}
- name: capture_radar
  id: variable_qtgui_push_button
  parameters:
    label: 'Capture Radar Image '
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: chan_est_file
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/chan_est.csv"'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    comment: 125 MHz -> 187
    gui_hint: 8,0,1,8
    label: TX/RX Sync
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '500'
    value: 187+5
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: ofdm_config.N_sc
  states: {}
- name: freq_smoothing
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,4,1,2
    label: '''Frequency    \nSmoothing'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: interp_factor_angle
  id: variable
  parameters:
    value: '16'
  states: {}
- name: mcs
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,8
    label: Modulation and Coding Scheme
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2","16QAM 3/4" ]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5] '
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: phase_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,2
    label: '''RX2 \nPhase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '-0.6'
  states: {}
- name: phase_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,2,1,2
    label: '''TX2 \n Phase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '-1.2'
  states: {}
- name: phase_tx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,4,1,2
    label: '''TX3 \n Phase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '1.5'
  states: {}
- name: phase_tx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,6,1,2
    label: '''TX4 \n Phase'''
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '2.2'
  states: {}
- name: phased_steering
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 20,2,1,2
    label: '''Phased Steering'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: radar_aided
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,2,1,2
    label: '''Radar-aided   \nPrecoding'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: radar_chan_file
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/radar_chan.csv"'
  states: {}
- name: radar_log_file
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/radar_log.csv"'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: usrp_freq+19e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: save_radar_log
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,6,1,2
    label: '''Saving    \nRadar Log'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '42'
  states: {}
- name: tx_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,2
    label: TX Scaling
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '4'
    value: '0.42'
  states: {}
- name: use_radar_streams
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 20,0,1,2
    label: '''Radar    \nStreams'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Range Resolution
    type: real
    value: R_res
  states: {state: disabled}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_freq
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    affinity: '9'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: (2+N_ltf)*(fft_len+cp_len)
    max_iter: '4000'
    scale: 1/((2+N_ltf)*(fft_len+cp_len))
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx2*cmath.exp(1j*phase_tx2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx3*cmath.exp(1j*phase_tx3)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_tx4*cmath.exp(1j*phase_tx4)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_rx2*cmath.exp(1j*phase_rx2)
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: N_tx*N_rx*interp_factor_angle
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    num_outputs: '2'
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '5000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_debug_0_1_0_0_0
  id: blocks_tag_debug
  parameters:
    name: MIMO PRECODER
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_1
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    comment: |-
      WINDOWING OPTIONS
      window.hanning(fft_len*interp_factor)
      window.rectangular(fft_len*interp_factor)
    fft_size: fft_len*interp_factor
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_len*interp_factor)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    comment: |-
      WINDOWING OPTIONS
      window.hanning(N_tx*N_rx*interp_factor_angle)
      window.rectangular(N_tx*N_rx*interp_factor_angle)
    fft_size: N_tx*N_rx*interp_factor_angle
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N_tx*N_rx*interp_factor_angle)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_3
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: helper_gui_heatmap_plot_0_0
  id: helper_gui_heatmap_plot
  parameters:
    autoscale_z: 'False'
    axis_x: angle_axis
    axis_y: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    comment: dynamic_range = 9 dB
    db_scale: 'True'
    dynamic_range_db: '9'
    interval: '100'
    label: Range-Angle Image
    len_key: '"packet_len"'
    vlen: N_tx*N_rx*interp_factor_angle
    x_axis_ticks: '[-70, 70, 10]'
    xlabel: '"Angle"'
    y_axis_ticks: '[0, 20, 4]'
    ylabel: '"Range (m)"'
  states: {state: disabled}
- name: helper_gui_time_plot_0_0
  id: helper_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[10, 40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {state: disabled}
- name: helper_gui_time_plot_0_0_0
  id: helper_gui_time_plot
  parameters:
    interval: '250'
    label: '"Angle Estimate"'
    time_window: '10'
    y_axis_lim: '[-70, 70]'
    y_label: '"Angle (degree)"'
    y_tag: '"angle"'
  states: {state: disabled}
- name: helper_gui_time_plot_0_0_0_0
  id: helper_gui_time_plot
  parameters:
    interval: '250'
    label: '"Range Estimate"'
    time_window: '10'
    y_axis_lim: '[0, 20]'
    y_label: '"Range (m)"'
    y_tag: '"range"'
  states: {state: disabled}
- name: helper_matrix_transpose_0
  id: helper_matrix_transpose
  parameters:
    debug: 'False'
    input_len: fft_len*interp_factor
    interp_factor: interp_factor_angle
    len_key: '"packet_len"'
    output_len: N_tx*N_rx
  states: {state: disabled}
- name: helper_mimo_encoder_0
  id: helper_mimo_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mod_encode: mcs
  states: {state: disabled}
- name: helper_mimo_ofdm_radar_0
  id: helper_mimo_ofdm_radar
  parameters:
    N_pre: len(ofdm_config.l_stf_ltf_64)+1
    N_rx: N_rx
    N_sym: N_tx
    N_tx: N_tx
    background_record: background_record
    background_removal: 'True'
    capture_sig: capture_radar
    debug: 'False'
    enable_tx_interleave: 'False'
    fft_len: fft_len
    interp_factor: interp_factor
    len_tag_key: '"packet_len"'
    radar_chan_file: radar_chan_file
    record_len: '8'
  states: {state: disabled}
- name: helper_mimo_precoder_0
  id: helper_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    affinity: '[7]'
    chan_est_file: chan_est_file
    chan_est_smoothing: freq_smoothing
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: '1000'
    phased_steering: 'False'
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: radar_aided
    radar_log_file: radar_log_file
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: use_radar_streams
  states: {state: disabled}
- name: helper_mimo_radar_estimator_2_0
  id: helper_mimo_radar_estimator_2
  parameters:
    N_pre: len(ofdm_config.l_stf_ltf_64)+1
    N_rx: N_rx
    N_sym: N_tx
    N_tx: N_tx
    background_record: background_record
    background_removal: 'True'
    debug: 'False'
    enable_tx_interleave: 'False'
    fft_len: fft_len
    interp_factor: interp_factor
    len_tag_key: '"packet_len"'
    record_len: '8'
  states: {state: disabled}
- name: helper_ofdm_cyclic_prefix_remover_0
  id: helper_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {state: disabled}
- name: helper_ofdm_cyclic_prefix_remover_0_0
  id: helper_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {state: disabled}
- name: helper_range_angle_estimator_0
  id: helper_range_angle_estimator
  parameters:
    angle_bins: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
    debug: 'False'
    len_key: '"packet_len"'
    noise_discard_angle: angle_res*2
    noise_discard_range: R_res*2
    power_threshold: '0'
    range_bins: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    snr_threshold: '15'
    stats_path: radar_log_file
    stats_record: save_radar_log
    vlen: N_tx*N_rx*interp_factor_angle
  states: {state: disabled}
- name: helper_usrp_mimo_trx_0
  id: helper_usrp_mimo_trx
  parameters:
    N_mboard: '2'
    N_rx: '2'
    N_tx: '4'
    affinity: '[6]'
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX,TX/RX,TX/RX"'
    args: '"addr0=192.168.120.2, addr1=192.168.101.2, master_clock_rate=250e6"'
    center_freq: usrp_freq
    clock_sources: '"external,external"'
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    num_delay_samps: delay_samp
    samp_rate: samp_rate
    time_sources: '"external,external"'
    timeout_rx: '0.5'
    timeout_tx: '0.5'
    update_period: '0.04'
    wait_rx: '0.01'
    wait_tx: '0.01'
    wire_rx: '""'
    wire_tx: '""'
  states: {state: disabled}
- name: helper_zero_pad_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: helper_zero_pad_0_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: helper_zero_pad_0_1
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: helper_zero_pad_0_1_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: mimo_ofdm_jrc_gui_heatmap_plot_0
  id: mimo_ofdm_jrc_gui_heatmap_plot
  parameters:
    autoscale_z: 'False'
    axis_x: angle_axis
    axis_y: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    comment: dynamic_range = 9 dB
    db_scale: 'True'
    dynamic_range_db: '9'
    interval: '100'
    label: Range-Angle Image
    len_key: '"packet_len"'
    vlen: N_tx*N_rx*interp_factor_angle
    x_axis_ticks: '[-70, 70, 10]'
    xlabel: '"Angle"'
    y_axis_ticks: '[0, 20, 4]'
    ylabel: '"Range (m)"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Range Estimate"'
    time_window: '10'
    y_axis_lim: '[0, 20]'
    y_label: '"Range (m)"'
    y_tag: '"range"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[10,40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_2
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Angle Estimate"'
    time_window: '10'
    y_axis_lim: '[-70,70]'
    y_label: '"Angle (degree)"'
    y_tag: '"angle"'
  states: {}
- name: mimo_ofdm_jrc_matrix_transpose_0
  id: mimo_ofdm_jrc_matrix_transpose
  parameters:
    debug: 'False'
    input_len: fft_len*interp_factor
    interp_factor: interp_factor_angle
    len_key: '"packet_len"'
    output_len: N_tx*N_rx
  states: {}
- name: mimo_ofdm_jrc_mimo_ofdm_radar_0
  id: mimo_ofdm_jrc_mimo_ofdm_radar
  parameters:
    N_pre: len(ofdm_config.l_stf_ltf_64)+1
    N_rx: N_rx
    N_sym: N_tx
    N_tx: N_tx
    background_record: background_record
    background_removal: 'True'
    capture_sig: capture_radar
    debug: 'False'
    enable_tx_interleave: 'False'
    fft_len: fft_len
    interp_factor: interp_factor
    len_tag_key: '"packet_len"'
    radar_chan_file: radar_chan_file
    record_len: '8'
  states: {}
- name: mimo_ofdm_jrc_mimo_precoder_0
  id: mimo_ofdm_jrc_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    affinity: '[7]'
    chan_est_file: chan_est_file
    chan_est_smoothing: freq_smoothing
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: '1000'
    phased_steering: 'False'
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: radar_aided
    radar_log_file: radar_log_file
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: use_radar_streams
  states: {}
- name: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0
  id: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {}
- name: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0_0
  id: mimo_ofdm_jrc_ofdm_cyclic_prefix_remover
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    len_key: '"packet_len"'
  states: {}
- name: mimo_ofdm_jrc_range_angle_estimator_0
  id: mimo_ofdm_jrc_range_angle_estimator
  parameters:
    angle_bins: np.arcsin( 2/(N_tx*N_rx*interp_factor_angle)*(np.arange(0, N_tx*N_rx*interp_factor_angle)-np.floor(N_tx*N_rx*interp_factor_angle/2)+0.5) )*180/cmath.pi
    debug: 'False'
    len_key: '"packet_len"'
    noise_discard_angle: angle_res*2
    noise_discard_range: R_res*2
    power_threshold: '0'
    range_bins: np.linspace(0, 3e8*fft_len/(2*samp_rate), fft_len*interp_factor)
    snr_threshold: '15'
    stats_path: radar_log_file
    stats_record: save_radar_log
    vlen: N_tx*N_rx*interp_factor_angle
  states: {}
- name: mimo_ofdm_jrc_stream_encoder_0
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mod_encode: mcs
  states: {}
- name: mimo_ofdm_jrc_usrp_mimo_trx_0
  id: mimo_ofdm_jrc_usrp_mimo_trx
  parameters:
    N_mboard: '2'
    N_rx: '2'
    N_tx: '4'
    affinity: '[6]'
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX,TX/RX,TX/RX"'
    args: '"addr0=192.168.120.2, addr1=192.168.101.2, master_clock_rate=250e6"'
    center_freq: usrp_freq
    clock_sources: '"external,external"'
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    num_delay_samps: delay_samp
    samp_rate: samp_rate
    time_sources: '"external,external"'
    timeout_rx: '0.5'
    timeout_tx: '0.5'
    update_period: '0.04'
    wait_rx: '0.01'
    wait_tx: '0.01'
    wire_rx: '""'
    wire_tx: '""'
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '5'
    pad_tail: (fft_len+cp_len)*3
  states: {}
- name: ofdm_config
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 4
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)

      # l_stf_ltf_128_custom = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, (-0-1j), (-0-1j), -1j, -1j, 1j, (-0-1j), -1j, 1j, 1j, (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), (-0-1j), 1j, 1j, 1j, 1j, 1j, -1j, 1j, (-0-1j), 1j, -1j, (-0-1j), 1j, 1j, -1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), 1j, -1j, 1j, (-0-1j), (-0-1j), 1j, 1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), 1j, 0, (-1-0j), -1, (-1+0j), 1, (1+0j), 1, (-1+0j), -1, (1+0j), 1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), 1, (1+0j), -1, (-1+0j), 1, (1+0j), 1, (1+0j), 1, (-1-0j), 1, (-1+0j), 1, (-1-0j), -1, (1+0j), 1, (-1-0j), -1, (-1+0j), -1, (-1-0j), -1, (1+0j), -1, (1+0j), -1, (-1+0j), 1, (1+0j), -1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), -1, (-1-0j), -1, 0j), 
      #     (0, 0, 1j, -1, -1j, 1, -1j, -1, -1j, -1, -1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, 1, 0, -1j, 1, 1j, 1, 1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, -1j, 1, -1j, 1, -1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, -1j, 1, 0))

      # l_stf_ltf_64 = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0),
      #  (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), 
      #     (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      # ltf_mapped_64 = np.array(ltf_mapped_64).T
      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,1
    label1: Power
    name: TX1 Power
    type: float
    unit1: dBm
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 12,0,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: RX1
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '50'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: MIMO Radar Channel
    size: N_tx*N_rx*12*fft_len
    srate: '1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 12,4,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: RX2
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '50'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: FFT - RX1
    size: fft_len*8
    srate: '1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 10,0,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: TX1
    size: (fft_len+cp_len)*40
    srate: '1'
    tr_delay: '20'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 10,4,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: TX2
    size: (fft_len+cp_len)*40
    srate: '1'
    tr_delay: '20'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: PRECODER 1
    size: fft_len*13
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: PRECODER 2
    size: fft_len*13
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 11,0,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: TX3
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '100'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_1_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 11,4,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: TX4
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '100'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: TX4
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RANGE-ANGLE
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RANGE-ANGLE
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX4
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', helper_gui_heatmap_plot_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', mimo_ofdm_jrc_gui_heatmap_plot_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0, '0', helper_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', mimo_ofdm_jrc_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', helper_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', helper_zero_pad_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', helper_zero_pad_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_2, '0']
- [blocks_nlog10_ff_0, '0', helper_gui_heatmap_plot_0_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_number_sink_0, '0']
- [blocks_null_source_0, '0', virtual_sink_1, '0']
- [blocks_null_source_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [blocks_socket_pdu_0, pdus, helper_mimo_encoder_0, pdu_in]
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', virtual_sink_0_1, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0, '0', virtual_sink_0_1_0, '0']
- [digital_ofdm_cyclic_prefixer_0_1, '0', virtual_sink_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0, '0', helper_mimo_ofdm_radar_0, '4']
- [fft_vxx_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '4']
- [fft_vxx_0_0_0, '0', helper_mimo_ofdm_radar_0, '5']
- [fft_vxx_0_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '5']
- [fft_vxx_0_1, '0', helper_matrix_transpose_0, '0']
- [fft_vxx_0_1, '0', mimo_ofdm_jrc_matrix_transpose_0, '0']
- [fft_vxx_0_1_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_1_0, '0', helper_range_angle_estimator_0, '0']
- [fft_vxx_0_1_0, '0', mimo_ofdm_jrc_range_angle_estimator_0, '0']
- [fft_vxx_0_2, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_2_0, '0', digital_ofdm_cyclic_prefixer_0_0_0, '0']
- [fft_vxx_0_3, '0', digital_ofdm_cyclic_prefixer_0_1, '0']
- [helper_matrix_transpose_0, '0', fft_vxx_0_1_0, '0']
- [helper_mimo_encoder_0, '0', helper_mimo_precoder_0, '0']
- [helper_mimo_ofdm_radar_0, '0', virtual_sink_0_1_0_0_0, '0']
- [helper_mimo_precoder_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [helper_mimo_precoder_0, '0', fft_vxx_0, '0']
- [helper_mimo_precoder_0, '0', helper_mimo_ofdm_radar_0, '0']
- [helper_mimo_precoder_0, '1', blocks_vector_to_stream_0_0_0_0_0, '0']
- [helper_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [helper_mimo_precoder_0, '1', helper_mimo_ofdm_radar_0, '1']
- [helper_mimo_precoder_0, '2', fft_vxx_0_3, '0']
- [helper_mimo_precoder_0, '2', helper_mimo_ofdm_radar_0, '2']
- [helper_mimo_precoder_0, '3', fft_vxx_0_2_0, '0']
- [helper_mimo_precoder_0, '3', helper_mimo_ofdm_radar_0, '3']
- [helper_ofdm_cyclic_prefix_remover_0, '0', fft_vxx_0_0, '0']
- [helper_ofdm_cyclic_prefix_remover_0_0, '0', fft_vxx_0_0_0, '0']
- [helper_range_angle_estimator_0, params, helper_gui_time_plot_0_0, stats]
- [helper_range_angle_estimator_0, params, helper_gui_time_plot_0_0_0, stats]
- [helper_range_angle_estimator_0, params, helper_gui_time_plot_0_0_0_0, stats]
- [helper_usrp_mimo_trx_0, '0', virtual_sink_1, '0']
- [helper_usrp_mimo_trx_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [helper_zero_pad_0, '0', blocks_null_sink_1, '1']
- [helper_zero_pad_0, '0', helper_usrp_mimo_trx_0, '1']
- [helper_zero_pad_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [helper_zero_pad_0_0, '0', blocks_null_sink_1, '0']
- [helper_zero_pad_0_0, '0', helper_usrp_mimo_trx_0, '0']
- [helper_zero_pad_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [helper_zero_pad_0_1, '0', blocks_null_sink_1, '2']
- [helper_zero_pad_0_1, '0', helper_usrp_mimo_trx_0, '2']
- [helper_zero_pad_0_1, '0', qtgui_time_sink_x_0_0_1_0_1, '0']
- [helper_zero_pad_0_1_0, '0', blocks_null_sink_1, '3']
- [helper_zero_pad_0_1_0, '0', helper_usrp_mimo_trx_0, '3']
- [helper_zero_pad_0_1_0, '0', qtgui_time_sink_x_0_0_1_0_1_0, '0']
- [mimo_ofdm_jrc_matrix_transpose_0, '0', fft_vxx_0_1_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_radar_0, '0', virtual_sink_0_1_0_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', fft_vxx_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', helper_mimo_ofdm_radar_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', mimo_ofdm_jrc_mimo_ofdm_radar_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', helper_mimo_ofdm_radar_0, '1']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', mimo_ofdm_jrc_mimo_ofdm_radar_0, '1']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', fft_vxx_0_3, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', helper_mimo_ofdm_radar_0, '2']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', mimo_ofdm_jrc_mimo_ofdm_radar_0, '2']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', fft_vxx_0_2_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', helper_mimo_ofdm_radar_0, '3']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', mimo_ofdm_jrc_mimo_ofdm_radar_0, '3']
- [mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0, '0', fft_vxx_0_0, '0']
- [mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0_0, '0', fft_vxx_0_0_0, '0']
- [mimo_ofdm_jrc_range_angle_estimator_0, params, helper_gui_time_plot_0_0_0, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, helper_gui_time_plot_0_0_0_0, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_0, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_range_angle_estimator_0, params, mimo_ofdm_jrc_gui_time_plot_2, stats]
- [mimo_ofdm_jrc_stream_encoder_0, '0', helper_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_stream_encoder_0, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '0', virtual_sink_1, '0']
- [mimo_ofdm_jrc_usrp_mimo_trx_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', helper_usrp_mimo_trx_0, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', helper_usrp_mimo_trx_0, '1']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '1']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', helper_usrp_mimo_trx_0, '2']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '2']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', helper_usrp_mimo_trx_0, '3']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', mimo_ofdm_jrc_usrp_mimo_trx_0, '3']
- [virtual_source_0_0, '0', fft_vxx_0_1, '0']
- [virtual_source_0_1, '0', helper_ofdm_cyclic_prefix_remover_0, '0']
- [virtual_source_0_1, '0', mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [virtual_source_0_1_0, '0', helper_ofdm_cyclic_prefix_remover_0_0, '0']
- [virtual_source_0_1_0, '0', mimo_ofdm_jrc_ofdm_cyclic_prefix_remover_0_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_0_0_0_0_1, '0']
- [virtual_source_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0_1_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [virtual_source_0_1_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']

metadata:
  file_format: 1
