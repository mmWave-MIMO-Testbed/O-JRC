options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ofdm_mimo_radar_TX
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: ofdm_config.N_ltf
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: ofdm_config.N_tx
  states: {}
- name: R_max
  id: variable
  parameters:
    value: 3e8*fft_len/(2*samp_rate)
  states: {}
- name: R_res
  id: variable
  parameters:
    value: 3e8/(2*samp_rate)
  states: {}
- name: amp_calib_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,3
    label: Amplitude Factor RX2
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1.63'
  states: {}
- name: amp_calib_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,3
    label: Amplitude Factor TX2
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1.83'
  states: {}
- name: angle_max
  id: variable
  parameters:
    value: np.rad2deg(np.arcsin((N_tx*N_rx*interp_factor-5)/(N_tx*N_rx*interp_factor)))
  states: {}
- name: chan_est_path
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/chan_est.csv"'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: delay_samp_1
  id: variable_qtgui_range
  parameters:
    label: TX/RX Delay [Samples]
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '500'
    value: '334'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: ofdm_config.N_sc
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: mcs
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,6
    label: Modulation and Coding Scheme
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2","16QAM 3/4" ]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5] '
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: phase_calib_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,3,1,3
    label: Phase Offset RX2
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '-1.65'
  states: {}
- name: phase_calib_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,3,1,3
    label: Phase Offset TX2
    orient: Qt.Horizontal
    start: '-2*cmath.pi'
    step: '0.01'
    stop: 2*cmath.pi
    value: '-3.73'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: usrp_freq+20e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: tx_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,2
    label: TX Multiplier
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '4'
    value: '0.3'
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Range Resolution
    type: real
    value: R_res
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_freq
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: (2+N_ltf)*(fft_len+cp_len)
    max_iter: '4000'
    scale: 1/((2+N_ltf)*(fft_len+cp_len))
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_calib_tx2*cmath.exp(1j*phase_calib_tx2)
    type: complex
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '5000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_debug_0_1_0_0_0
  id: blocks_tag_debug
  parameters:
    name: MIMO PRECODER
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_0_1_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: CYCLIC
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_1_0_0_0_1
  id: blocks_tag_debug
  parameters:
    name: Encoder
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: helper_mimo_encoder_0
  id: helper_mimo_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    minoutbuf: '65536'
    mod_encode: mcs
  states: {state: disabled}
- name: helper_mimo_precoder_0
  id: helper_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    chan_est_file: '""'
    chan_est_smoothing: 'False'
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: '65536'
    phased_steering: 'False'
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: 'False'
    radar_log_file: '""'
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: 'False'
  states: {state: disabled}
- name: helper_sync_mimo_trx_0
  id: helper_sync_mimo_trx
  parameters:
    N_mboard: '1'
    N_rx: '2'
    N_tx: '2'
    alias: block_0
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX"'
    args_rx: '"addr=192.168.100.2,master_clock_rate=250e6"'
    args_tx: '"addr=192.168.100.2,master_clock_rate=250e6"'
    center_freq: usrp_freq
    clock_source_rx: '"internal"'
    clock_source_tx: '"internal"'
    comment: |-
      master_clock_rate=200e6
      ,ignore-cal-file=1
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    lo_offset_tx: '0'
    minoutbuf: 300*(fft_len+cp_len)
    num_delay_samps: delay_samp_1
    samp_rate: samp_rate
    time_source_rx: '"internal"'
    time_source_tx: '"internal"'
    timeout_rx: '1.0'
    timeout_tx: '1.0'
    update_period: '0.1'
    wait_rx: '0.02'
    wait_tx: '0.02'
    wire_rx: '""'
    wire_tx: '""'
  states: {state: disabled}
- name: helper_zero_pad_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: '100'
  states: {state: disabled}
- name: helper_zero_pad_0_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: '100'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: mimo_ofdm_jrc_mimo_precoder_0
  id: mimo_ofdm_jrc_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    chan_est_file: '""'
    chan_est_smoothing: 'False'
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    phased_steering: 'False'
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: 'False'
    radar_log_file: '""'
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: 'False'
  states: {}
- name: mimo_ofdm_jrc_stream_encoder_0
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    minoutbuf: '65536'
    mod_encode: mcs
  states: {}
- name: mimo_ofdm_jrc_sync_mimo_trx_0
  id: mimo_ofdm_jrc_sync_mimo_trx
  parameters:
    N_mboard: '1'
    N_rx: '2'
    N_tx: '2'
    alias: block_0
    antenna_rx: '"RX2,RX2"'
    antenna_tx: '"TX/RX,TX/RX"'
    args_rx: '"addr=192.168.100.2,master_clock_rate=250e6"'
    args_tx: '"addr=192.168.100.2,master_clock_rate=250e6"'
    center_freq: usrp_freq
    clock_source_rx: '"internal"'
    clock_source_tx: '"internal"'
    comment: |-
      master_clock_rate=200e6
      ,ignore-cal-file=1
    debug: 'False'
    gain_rx: rx_gain
    gain_tx: tx_gain
    len_key: '"packet_len"'
    lo_offset_rx: '0'
    lo_offset_tx: '0'
    minoutbuf: 300*(fft_len+cp_len)
    num_delay_samps: delay_samp_1
    samp_rate: samp_rate
    time_source_rx: '"internal"'
    time_source_tx: '"internal"'
    timeout_rx: '1.0'
    timeout_tx: '1.0'
    update_period: '0.1'
    wait_rx: '0.02'
    wait_tx: '0.02'
    wire_rx: '""'
    wire_tx: '""'
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: '100'
  states: {}
- name: mimo_ofdm_jrc_zero_pad_1
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    minoutbuf: 300*(fft_len+cp_len)
    pad_front: '0'
    pad_tail: '100'
  states: {}
- name: ofdm_config
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 2
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)

      # l_stf_ltf_128_custom = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, (-0-1j), (-0-1j), -1j, -1j, 1j, (-0-1j), -1j, 1j, 1j, (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), (-0-1j), 1j, 1j, 1j, 1j, 1j, -1j, 1j, (-0-1j), 1j, -1j, (-0-1j), 1j, 1j, -1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), 1j, -1j, 1j, (-0-1j), (-0-1j), 1j, 1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), 1j, 0, (-1-0j), -1, (-1+0j), 1, (1+0j), 1, (-1+0j), -1, (1+0j), 1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), 1, (1+0j), -1, (-1+0j), 1, (1+0j), 1, (1+0j), 1, (-1-0j), 1, (-1+0j), 1, (-1-0j), -1, (1+0j), 1, (-1-0j), -1, (-1+0j), -1, (-1-0j), -1, (1+0j), -1, (1+0j), -1, (-1+0j), 1, (1+0j), -1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), -1, (-1-0j), -1, 0j), 
      #     (0, 0, 1j, -1, -1j, 1, -1j, -1, -1j, -1, -1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, 1, 0, -1j, 1, 1j, 1, 1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, -1j, 1, -1j, 1, -1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, -1j, 1, 0))

      # l_stf_ltf_64 = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0),
      #  (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), 
      #     (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      # ltf_mapped_64 = np.array(ltf_mapped_64).T
      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,1
    label1: Power
    name: TX1 Power
    type: float
    unit1: dBm
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 8,0,1,6
    label1: ''
    label2: ''
    name: Signal TX1
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '200'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: Signal SENT FFT
    size: fft_len*8
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: PRECODER 1
    size: fft_len*13
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: PRECODER 2
    size: fft_len*13
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 7,0,1,1
    label1: ''
    label2: ''
    name: Signal RX
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '100'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_2
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: Signal TX2
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '200'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: usrp_freq
    center_freq1: usrp_freq
    dev_addr: '"addr=192.168.120.2,master_clock_rate=200e6"'
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0, '0', helper_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', mimo_ofdm_jrc_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', helper_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', mimo_ofdm_jrc_zero_pad_1, '0']
- [blocks_nlog10_ff_1, '0', qtgui_number_sink_0, '0']
- [blocks_socket_pdu_0, pdus, helper_mimo_encoder_0, pdu_in]
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_0, pdu_in]
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_tag_debug_0_1_0_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', virtual_sink_0_1, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_2, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [helper_mimo_encoder_0, '0', blocks_tag_debug_0_1_0_0_0_1, '0']
- [helper_mimo_encoder_0, '0', helper_mimo_precoder_0, '0']
- [helper_mimo_precoder_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [helper_mimo_precoder_0, '0', fft_vxx_0, '0']
- [helper_mimo_precoder_0, '1', blocks_vector_to_stream_0_0_0_0_0, '0']
- [helper_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [helper_sync_mimo_trx_0, '0', blocks_null_sink_0, '0']
- [helper_sync_mimo_trx_0, '1', blocks_null_sink_0_0, '0']
- [helper_sync_mimo_trx_0, '1', qtgui_time_sink_x_0_0_1_1, '0']
- [helper_zero_pad_0, '0', helper_sync_mimo_trx_0, '1']
- [helper_zero_pad_0, '0', qtgui_time_sink_x_0_0_1_2, '0']
- [helper_zero_pad_0, '0', uhd_usrp_sink_0, '1']
- [helper_zero_pad_0_0, '0', helper_sync_mimo_trx_0, '0']
- [helper_zero_pad_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [helper_zero_pad_0_0, '0', uhd_usrp_sink_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', fft_vxx_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', blocks_vector_to_stream_0_0_0_0_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [mimo_ofdm_jrc_stream_encoder_0, '0', helper_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_stream_encoder_0, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_sync_mimo_trx_0, '0', blocks_null_sink_0, '0']
- [mimo_ofdm_jrc_sync_mimo_trx_0, '1', blocks_null_sink_0_0, '0']
- [mimo_ofdm_jrc_sync_mimo_trx_0, '1', qtgui_time_sink_x_0_0_1_1, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', helper_sync_mimo_trx_0, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_sync_mimo_trx_0, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [mimo_ofdm_jrc_zero_pad_1, '0', helper_sync_mimo_trx_0, '1']
- [mimo_ofdm_jrc_zero_pad_1, '0', mimo_ofdm_jrc_sync_mimo_trx_0, '1']
- [mimo_ofdm_jrc_zero_pad_1, '0', qtgui_time_sink_x_0_0_1_2, '0']
- [virtual_source_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
